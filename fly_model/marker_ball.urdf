Commit message: virtual tether and CoG link

File: fly_model/marker_ball.urdf (robot description, URDF)
Before this commit: robot marker_ball, 1 links, 0 joints
Links:
- link ball: mass None -> 1; geometry visual sphere radius=0.05
